# Repository abenstirling/SASG

File README.md:

# SASG
USB-powered, single-channel, low-frequency <b>S</b>ignal <b>A</b>nalyser and <b>S</b>ignal <b>G</b>enerator. 

## Features
* STM32F103CBT6
* USB-C Power/Communication
* Single-channel
* Low-frequency
* Signal Analyser
* Signal Generator
* 20Hz - 20kHz

## KiCad design SASG/Nemesis-MixSigPCB.kicad_pcb

Parts:
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3

Notes on the sheet:
[4] DAC
Mixed-Signal Demo PCB
FIDUCIALS
[3] ADC
Mounting Holes (M3)
[2] MCU
[1] Power

Parts:
C100, C101: 1u; C_0603_1608Metric
C102, C103, C104, C105, C107: 22u; C_0805_2012Metric
C106: DNP; C_0402_1005Metric
C108: 100n; C_0402_1005Metric
D100: GREEN; LED_0603_1608Metric
L100: 10n; L_0402_1005Metric
L101: 15u; L_Bourns-SRN4018
R100: 10R; R_0805_2012Metric
R101: 100k; R_0402_1005Metric
R102: 22k; R_0402_1005Metric
R103, R104, R105: 1k; R_0402_1005Metric
U100: HT7533-1; SOT-89-3
U101: TLV62569DBV; SOT-23-5
U102: MCP6001T-E/OT; SOT-23-5

Connections:
+3.3VA: C103.1, C108.1, R104.2, U100.3 (VOUT), U102.5 (V+); also elsewhere on the board
+3V3: C105.1, C106.1, D100.2 (A), L101.2, R101.2; also elsewhere on the board
+5V: C101.1, C104.1, L100.2, R100.2, U101.1 (EN), U101.4 (VIN); also elsewhere on the board
/Power/+5V_FILT: C102.1, R100.1, U100.2 (VIN)
/Power/BUCK_FB: C106.2, R101.1, R102.2, U101.5 (FB)
/Power/BUCK_SW: L101.1, U101.3 (SW)
/Power/LED_PWR_K: D100.1 (K), R103.2
/Power/VREF: C107.1, R104.1, R105.2, U102.3 (+)
GND: C100.2, C101.2, C102.2, C103.2, C104.2, C105.2, C107.2, C108.2, R102.1, R103.1, R105.1, U100.1 (GND), U101.2 (GND), U102.2 (V-); also elsewhere on the board
VBUS: C100.1, L100.1; also elsewhere on the board
VCOM: U102.1, U102.4 (-); also elsewhere on the board

Notes on the sheet:
DCR=0R15
C(in/out)>10uF
V(out)=0.6*(1+100k/22k)=3.327V
I(DC)=500mA
Bias Generator
LP filter: fc=15Hz
100mA max.
f(sw)=1.5MHz
VBUS power comes from USB Type C connector (schematic page 2)
P(R)>1/8W
I(load)=0.25A max
Input Filtering & Analogue and Digital Supplies
[1] Power
WEBENCH Tools

Parts:
C200: 10u; C_0603_1608Metric
C201, C202, C203, C204, C210, C211, C212: 100n; C_0402_1005Metric
C205: 10n; C_0402_1005Metric
C206, C207: 1u; C_0603_1608Metric
C208, C209: 10p; C_0402_1005Metric
D200: ASMB-MTB1-0A3A2; LED_Avago_PLCC4_3.2x2.8mm_CW
D201, D202, D203, D204, D205: PESD3V3L1BA,115; D_SOD-323
J200: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J201: 2x5 1.27mm; PinHeader_2x05_P1.27mm_Vertical_SMD
L200: 10n; L_0402_1005Metric
L201: CMF3216F-900-2P-T; L_CommonMode_Wurth_WE-CNSW-1206
R200, R202, R203: 10k; R_0402_1005Metric
R201: 0R; R_0402_1005Metric
R204: 1k5; R_0402_1005Metric
R205, R206: 5k1; R_0402_1005Metric
R207, R208, R209: 1k; R_0402_1005Metric
R210, R211, R212, R213: 49R9; R_0402_1005Metric
U200: STM32F103CBT6; LQFP-48_7x7mm_P0.5mm
U201: USBLC6-2SC6; SOT-23-6
Y200: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C200.1, C201.1, C202.1, C203.1, C204.1, C207.1, C211.1, D200.4 (A), D201.1 (A1), J201.1, L200.2, R202.1, R203.1, R204.1, U200.1 (VBAT), U200.24 (VDD), U200.36 (VDD), U200.48 (VDD); also elsewhere on the board
/MCU/BOOT0: R200.1, U200.44 (BOOT0)
/MCU/CONN_NRST: D205.1 (A1), J201.6, R213.2
/MCU/CONN_SWCLK: D203.1 (A1), J201.9, R211.2
/MCU/CONN_SWDIO: D202.1 (A1), J201.10, R210.2
/MCU/CONN_SWO: D204.1 (A1), J201.8, R212.2
/MCU/HSE_IN: C208.1, U200.5 (PD0), Y200.1
/MCU/HSE_OUT: R201.1, U200.6 (PD1)
/MCU/LED_B_K: D200.3 (BK), R209.2
/MCU/LED_G_K: D200.2 (GK), R208.2
/MCU/LED_R_K: D200.1 (RK), R207.2
/MCU/NRST: C212.1, R213.1, U200.7 (NRST)
/MCU/SWCLK: R211.1, U200.37 (PA14)
/MCU/SWDIO: R210.1, U200.34 (PA13)
/MCU/SWO: R212.1, U200.39 (PB3)
/MCU/TIM4_CH1: R208.1, U200.42 (PB6)
/MCU/TIM4_CH2: R209.1, U200.43 (PB7)
/MCU/TIM4_CH3: R207.1, U200.45 (PB8)
/MCU/USB_CMC_D+: L201.2, U201.4 (I/O2)
/MCU/USB_CMC_D-: L201.1, U201.6 (I/O1)
/MCU/USB_CONN_CC1: J200.A5 (CC1), R205.1
/MCU/USB_CONN_CC2: J200.B5 (CC2), R206.1
/MCU/USB_CONN_D+: J200.A6 (D+), J200.B6 (D+), U201.3 (I/O2)
/MCU/USB_CONN_D-: J200.A7 (D-), J200.B7 (D-), U201.1 (I/O1)
/MCU/USB_D+: L201.3, R204.2, U200.33 (PA12)
/MCU/USB_D-: L201.4, U200.32 (PA11)
/MCU/XTAL_IN: C209.1, R201.2, Y200.3
DAC_NCLR: U200.20 (PB2); also elsewhere on the board
DAC_NLDAC: U200.21 (PB10); also elsewhere on the board
GND: C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, D201.2 (A2), D202.2 (A2), D203.2 (A2), D204.2 (A2), D205.2 (A2), J200.A1 (GND), J200.A12 (GND), J200.B1 (GND), J200.B12 (GND), J201.2, J201.3, J201.5, R200.2, R205.2, R206.2, U200.8 (VSSA), U200.23 (VSS), U200.35 (VSS), U200.47 (VSS), U201.2 (GND), Y200.2, Y200.4; also elsewhere on the board
SPI1_MISO: U200.16 (PA6); also elsewhere on the board
SPI1_NSS: R203.2, U200.14 (PA4); also elsewhere on the board
SPI1_SCK: U200.15 (PA5); also elsewhere on the board
SPI2_MOSI: U200.28 (PB15); also elsewhere on the board
SPI2_NSS: R202.2, U200.25 (PB12); also elsewhere on the board
SPI2_SCK: U200.26 (PB13); also elsewhere on the board
VBUS: C210.1, J200.A4 (VBUS), J200.A9 (VBUS), J200.B4 (VBUS), J200.B9 (VBUS), U201.5 (VBUS); also elsewhere on the board
VDDA: C205.1, C206.1, L200.1, U200.9 (VDDA)

Notes on the sheet:
Signal Path: Connector <-> ESD Protection <-> Common-Mode Choke <-> Pull-Up <-> MCU
RGB LED
Crystal app note: AN2867
SWD Header
USB App Note: AN4879
Common-Mode Choke Impedance: 90R
[2] Microcontroller & USB
CL=10pF ESR=80R
MCU (STM32F1)
USB Type C

Parts:
C300, C304, C307: 150p; C_0402_1005Metric
C301, C302, C306, C311, C313, C314: 100n; C_0402_1005Metric
C303, C305: 1n; C_0402_1005Metric
C308, C309, C310, C312, C315: 10u; C_0603_1608Metric
D300: PESD3V3L1BA,115; D_SOD-323
J300: 031-5640-1010
R300, R306, R307: 1k; R_0402_1005Metric
R301, R302: 2M2; R_0402_1005Metric
R303: 6k8; R_0402_1005Metric
R304: 22k; R_0402_1005Metric
R305: 12k; R_0402_1005Metric
R308: 49R9; R_0402_1005Metric
R309: 0R; R_0402_1005Metric
U300, U301: MCP6001T-E/OT; SOT-23-5
U302: REF3033AIDBZT; SOT-23
U303: ADC141S626CIMM_NOPB; SOP50P490X110-10N

Connections:
+3.3VA: C302.1, C306.1, C312.1, C313.1, U300.5 (V+), U301.5 (V+), U303.10 (VA); also elsewhere on the board
+3V3: C314.1, C315.1, U303.9 (VIO); also elsewhere on the board
+5V: C308.1, R308.2; also elsewhere on the board
/ADC/ADC_IN+: C307.1, R306.1, U303.2 (+IN)
/ADC/ADC_IN-: C307.2, R307.1, U303.3 (-IN)
/ADC/ADC_SCLK: R309.2, U303.8 (SCLK)
/ADC/ADC_VREF: C310.1, C311.1, U302.2 (OUT), U303.1 (VREF)
/ADC/ADC_VREF_VIN: C309.1, R308.1, U302.1 (IN)
/ADC/IN: D300.1 (A1), J300.1 (In), R300.2
/ADC/IN_AA_BUF_IN: C304.1, R305.1, U301.3 (+)
/ADC/IN_AA_BUF_OUT: C305.2, R306.2, U301.1, U301.4 (-)
/ADC/IN_BUF: C301.1, R302.1, U300.3 (+)
/ADC/IN_BUF_OUT: R303.2, U300.1, U300.4 (-)
/ADC/IN_RF: C300.1, C301.2, R300.1, R301.2
GND: C300.2, C302.2, C303.2, C304.2, C306.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, D300.2 (A2), J300.2 (Ext), R301.1, U300.2 (V-), U301.2 (V-), U302.3 (GND), U303.4 (GND), U303.5 (GND); also elsewhere on the board
unnamed: C303.1, R303.1, R304.2
unnamed: C305.1, R304.1, R305.2
SPI1_MISO: U303.7 (DOUT); also elsewhere on the board
SPI1_NSS: U303.6 (NCS); also elsewhere on the board
SPI1_SCK: R309.1; also elsewhere on the board
VCOM: R302.2, R307.2; also elsewhere on the board

Notes on the sheet:
HP filter: fc=1.4Hz
Both ADC inputs should be at same VCOM
BNC connector
Rin = 1.1M
14-Bit S/H ADC
Vref filter: fc=319Hz
Input voltage must be in -1.65V to +1.65V range!
Analogue Front-End
Single-ended to 'balanced' conversion
RF filter: fc=1.1MHz
3rd order Butterworth anti-aliasing (low-pass filter) fc=25kHz
MCP6001: I/O Rail-to-Rail, Single-Supply (1V8 to 5V), high-impedance input CMOS, low bias currents, unity gain stable
P(R,max)=0.1W -> I(R,max)=45mA
Vref=3V3
[3] ADC & Analogue Front-End

Parts:
C400: 10u; C_0603_1608Metric
C401, C406: 100n; C_0402_1005Metric
C402: 1u; C_0603_1608Metric
C403, C405: 1n; C_0402_1005Metric
C404: 150p; C_0402_1005Metric
D400: PESD3V3L1BA,115; D_SOD-323
J400: 031-5640-1010
R400: 0R; R_0402_1005Metric
R401: 10k; R_0402_1005Metric
R402: 6k8; R_0402_1005Metric
R403: 22k; R_0402_1005Metric
R404: 12k; R_0402_1005Metric
R405: 49R9; R_0402_1005Metric
U400: DAC7563SDGSR; SOP50P490X110-10N
U401: MCP6001T-E/OT; SOT-23-5

Connections:
+3.3VA: C406.1, U401.5 (V+); also elsewhere on the board
+3V3: C400.1, C401.1, U400.9 (AVDD); also elsewhere on the board
/DAC/DAC_OUT_A: R402.2, U400.1 (VOUT_A)
/DAC/DAC_OUT_B: R401.1, U400.2 (VOUT_B)
/DAC/DAC_SCLK: R400.2, U400.7 (SCLK)
/DAC/DAC_VREF: C402.1, U400.10 (VREFIN/VREFOUT)
/DAC/OUT: D400.1 (A1), J400.1 (In), R405.1
/DAC/OUT_AA_BUF_IN: C404.1, R404.1, U401.3 (+)
/DAC/OUT_AA_BUF_OUT: C405.2, R405.2, U401.1, U401.4 (-)
DAC_NCLR: U400.5 (NCLR); also elsewhere on the board
DAC_NLDAC: U400.4 (NLDAC); also elsewhere on the board
GND: C400.2, C401.2, C402.2, C403.2, C404.2, C406.2, D400.2 (A2), J400.2 (Ext), R401.2, U400.3 (GND), U401.2 (V-); also elsewhere on the board
unnamed: C403.1, R402.1, R403.2
unnamed: C405.1, R403.1, R404.2
SPI2_MOSI: U400.8 (DIN); also elsewhere on the board
SPI2_NSS: U400.6 (NSYNC); also elsewhere on the board
SPI2_SCK: R400.1; also elsewhere on the board

Notes on the sheet:
[4] DAC & Analogue Output Circuitry
Anti-Aliasing Filter and Output Connector (BNC)
Rout=50R
Output voltage will be in 0V to +3.3V range!
DAC
C(Vref,min)=150nF
3rd order Butterworth anti-aliasing (low-pass filter) fc=25kHz
DC offset (op-amp bias) generated by DAC

Board: 4 copper layers, 50.0 x 70.0 mm, 117 parts (0 on the bottom side), 68 nets.
